Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:51+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-72313
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Комплекс игровой детский, ZSK-72313 Игровой комплекс «Спиральная Горка»
In: Площадка
Description: Комплекс игровой детский. Игровой комплекс «Спиральная Горка»; Classification: 59.1.15.01-0242 Горка (Классификатор строительных ресурсов (КСР)); Material: Нержавеющая сталь, атмосферостойкий HDPE, армированные канат
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-72313; ModelReference: Игровой комплекс «Спиральная Горка»; ProductionYear: 2026; ArticleNumber: ZSK-72313
ORION_Изделие - Артикул: ZSK-72313; Артикул прежний: SD-72313; Наименование: Игровой комплекс «Спиральная Горка»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 5.2 x 5.2 м; Зона безопасности: 8.8 x 8.8 м; Высота свободного падения: 1.8 м; Возраст: для детей от 2 до 12 лет; Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; Цена: 4 100 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/play-complexes/377; Код КСИ: CPr>EDB030; Класс КСИ: Горка; Коды КСР: 59.1.15.01-0242 … 59.1.15.01-0305
ADSK - ADSK_Наименование: Игровой комплекс «Спиральная Горка»; ADSK_Марка: ZSK-72313; ADSK_Код изделия: 59.1.15.01-0242; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; ADSK_URL страницы изделия: https://зск.рф/catalog/play-complexes/377
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 8.8 x 8.8 м; ZSK_Высота_свободного_падения: 1.8 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB030; ZSK_Артикул_прежний: SD-72313
Qto_ORION - Длина: 5200 mm; Ширина: 5200 mm; Высота: 0 mm
